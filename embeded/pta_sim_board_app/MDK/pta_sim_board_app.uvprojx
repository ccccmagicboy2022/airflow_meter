# Keil uVision project pta_sim_board_app.uvprojx, settings and files
target flashcode (6160000::V6.16::ARMCLANG)
  device: N32G4FRKEQ7 Nationstech
  pack: Nationstech.N32G4FR_DFP.1.0.1
  cpu: IRAM(0x20000000,0x24000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: flashcode +hex
  AfterMake: fromelf --bin -o ".\bin\@L.bin" "#L"
  AfterMake: fromelf -c "#L" -o "$L@L.asm"
  c flags: OneElfS=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: N32G4FR, USE_STDPERIPH_DRIVER, SYSCLK_FREQ=128000000,USE_DEVICE_DRIVER_LIB,_CC_ARM,ARM_MATH_CM4,SYSCLK_SRC=SYSCLK_USE_HSI_PLL
  c include: ..\application\app;..\application\HardFaultHandlerMDK;..\application\rtt;..\cmsis;..\common;..\driver\Inc;..\source;..\bsp\inc;..\application\nr_micro_shell;..\application\EventRecorder;..\application\fifo;..\application\bsp;..\application\adc;..\application\hardware;..\application\uart;..\application\clk;..\application\do;..\application\DWTDelay;..\application\shell;..\application\app;..\application\systick;..\application\log;..\application\dac
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20020000 size 0x4000
  group cpp
    ../source/: main.cpp nr_micro_shell_commands.cpp
    ../application/hardware/: hardware.cpp
    ../application/uart/: uart.cpp
    ../application/clk/: clk.cpp
    ../application/rtt/: rtt.cpp
    ../application/do/: do.cpp
    ../application/DWTDelay/: DWTDelay.cpp
    ../application/shell/: shell.cpp
    ../application/app/: app.cpp
    ../application/systick/: systick.cpp
    ../application/dac/: dac.cpp
  group src
    ../application/fifo/: fifo.c
    ../application/bsp/: bsp.c
    ../application/nr_micro_shell/: ansi.c ansi_port.c nr_micro_shell.c
    ../source/: sys.h
    ../application/log/: log.c
  group common
    ../common/: system_n32g4fr.c startup_n32g4fr.s n32g4fr_it.c
  group driver
    ../driver/src/: misc.c n32g4fr_adc.c n32g4fr_bkp.c n32g4fr_can.c n32g4fr_crc.c n32g4fr_dac.c n32g4fr_dbg.c n32g4fr_dma.c n32g4fr_dvp.c n32g4fr_exti.c n32g4fr_flash.c n32g4fr_gpio.c n32g4fr_i2c.c n32g4fr_iwdg.c n32g4fr_pwr.c n32g4fr_qspi.c n32g4fr_rcc.c n32g4fr_rtc.c n32g4fr_sdio.c n32g4fr_spi.c n32g4fr_tim.c n32g4fr_tsc.c n32g4fr_usart.c n32g4fr_wwdg.c n32g4fr_xfmc.c
  group debug
    ../application/HardFaultHandlerMDK/: SEGGER_HardFaultHandler.c HardFaultHandler.S
    ../application/rtt/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group doc
    ../: 说明.txt
target ramcode (6160000::V6.16::ARMCLANG)
  device: N32G4FRKEQ7 Nationstech
  pack: Nationstech.N32G4FR_DFP.1.0.1
  cpu: as above
  output: ramcode
  AfterMake: fromelf --bin -o ".\bin\@L.bin" "#L"
  AfterMake: fromelf -c "#L" -o "$L@L.asm"
  c flags: OneElfS=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: VECT_TAB_SRAM,N32G4FR, USE_STDPERIPH_DRIVER, SYSCLK_FREQ=128000000,USE_DEVICE_DRIVER_LIB,_CC_ARM,ARM_MATH_CM4,SYSCLK_SRC=SYSCLK_USE_HSI_PLL
  c include: ..\application\app;..\application\HardFaultHandlerMDK;..\application\rtt;..\cmsis;..\common;..\driver\Inc;..\source;..\bsp\inc;..\application\hardware;..\application\nr_micro_shell;..\application\adc;..\application\EventRecorder;..\application\fifo;..\application\uart;..\application\clk;..\application\do;..\application\DWTDelay;..\application\shell;..\application\bsp;..\application\systick;..\application\log;..\application\dac
  memory RVCT4: ROM 0x20000000 size 0x10000
  memory RVCT9: RAM 0x20010000 size 0x10000
  memory RVCT10: RAM 0x20020000 size 0x4000
